# IAR project DogCollar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32U575ZI ST STM32U575ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; STM32U575xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\bsp\drivers\; ..\bsp\drivers\include; ..\bsp\drivers\config; ..\bsp\drivers; ..\bsp\libraries\inc; ..\bsp\libraries\CMSIS; ..\bsp\libraries\CMSIS\Include; ..\bsp\libraries\CMSIS\Device\ST\STM32U5xx\Include; ..\bsp\libraries\STM32U5xx_HAL_Driver\Inc; ..\os\rt-thread5.0.1\include\; ..\os\rt-thread5.0.1\include\libc; ..\os\rt-thread5.0.1\components\cplusplus; ..\os\rt-thread5.0.1\components\drivers\include\; ..\os\rt-thread5.0.1\components\drivers\include\drivers; ..\os\rt-thread5.0.1\components\drivers\include\ipc; ..\os\rt-thread5.0.1\components\finsh; ..\os\rt-thread5.0.1\components\libc\compilers\dlib; ..\os\rt-thread5.0.1\components\libc\compilers\newlib\sys; ..\os\rt-thread5.0.1\components\libc\compilers\common; ..\os\rt-thread5.0.1\components\libc\compilers\common\extension; ..\os\rt-thread5.0.1\components\libc\compilers\common\include; ..\os\rt-thread5.0.1\components\libc\compilers\common\extension\fcntl\octal; ..\os\rt-thread5.0.1\components\libc\posix\io\poll; ..\os\rt-thread5.0.1\components\utilities\ulog; ..\os\rt-thread5.0.1\components\utilities\utest; ..\os\rt-thread5.0.1\components\utilities\ymodem; ..\os\rt-thread5.0.1\components\dfs\dfs_v1\include; ..\os\rt-thread5.0.1\components\dfs\dfs_v1\filesystems\devfs; ..\os\rt-thread5.0.1\components\dfs\dfs_v0\filesystems\uffs; ..\os\rt-thread5.0.1\components\dfs\dfs_v0\filesystems\uffs\src\inc; ..\os\rt-thread5.0.1\components\dfs\dfs_v0\filesystems\uffs\storage\nor; ..\packages\packages\syswatch-latest\inc; ..\packages\packages\cJSON-v1.0.2; ..\packages\packages\quick_led-latest\inc; ..\packages\packages\easyblink-v2.0.1; ..\; ..\app\; ..\app\system\inc; ..\app\public\inc; ..\app\hci; ..\app\hci\common\inc; ..\app\hci\msh; ..\app\hci\ittes; ..\app\hci\utest; ..\app\at_client\common; ..\app\at_client\bg77\inc; ..\app\at_client\esp\inc; ..\app\oam; ..\app\oam\service\inc; ..\app\oam\json; ..\app\oam\lan; ..\app\business\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\output\iar\Debug\$PROJ_FNAME$.bin
  postbuild: cmd /c "python ..\tools\create_image.py ..\ Debug output\bootload.bin $PROJ_FNAME$ $CONFIG_NAME$"
  ILINK.IlinkOutputFile: DogCollar.out
  ILINK.IlinkIcfFile: ..\bsp\ld\stm32u575xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../app/: app_def.h app_lib.h main.c ReadMe.txt rtconfig.h type.h version.h
  group app/at_client/bg77
    ../app/at_client/bg77/: bg77.c bg77_cart.c bg77_cmd.c bg77_file.c bg77_ftp.c bg77_https.c bg77_mqtt.c bg77_tcpip.c
  group app/at_client/bg77/inc
    ../app/at_client/bg77/inc/: bg77.h bg77_cart.h bg77_cmd.h bg77_file.h bg77_ftp.h bg77_https.h bg77_mqtt.h bg77_tcpip.h
  group app/at_client/common
    ../app/at_client/common/: at.c at.h at_client.c at_client.h at_if.h at_type.h
  group app/at_client/esp
    ../app/at_client/esp/: esp.c esp_bt.c esp_cmd.c esp_https.c esp_mqtt.c esp_tcpip.c
  group app/at_client/esp/inc
    ../app/at_client/esp/inc/: esp.h esp_bt.h esp_cmd.h esp_https.h esp_mqtt.h esp_tcpip.h esp_wifi.h
  group app/business
    ../app/business/: adc_thread.c adc_thread.h business.c business.h
  group app/hci/common
    ../app/hci/common/: app_gpio.c app_led.c app_misc.c app_ulog.c
  group app/hci/common/inc
    ../app/hci/common/inc/: app_gpio.h app_init.h app_key.h app_led.h app_ulog.h ulog_lvl.h
  group app/hci/ittes
    ../app/hci/ittes/: ittes_main.c
  group app/hci/msh
    ../app/hci/msh/: msh_bg77.c msh_board.c msh_config.c msh_debug.c msh_esp32.c msh_lan.c msh_led.c msh_pm.c msh_show.c msh_smart.c msh_system.c
  group app/hci/utest
    ../app/hci/utest/: utext_adc.c utext_bg77.c utext_ble.c utext_flash.c utext_led.c utext_lsm6d.c utext_wifi.c
  group app/oam
    ../app/oam/: oam_port.c oam_port.h oam_thread.c oam_thread.h
  group app/oam/lan
    ../app/oam/lan/: lan.c lan.h lan_get.c lan_set.c
  group app/oam/service
    ../app/oam/service/: esp_btser.c esp_client.c quectel_client.c
  group app/oam/service/inc
    ../app/oam/service/inc/: esp_btser.h esp_client.h quectel_client.h
  group app/oam/smart
    ../app/oam/json/: smart.def smart_analy.c smart_analy.h smart_devget.c smart_devset.c smart_port.c smart_port.h
  group app/public
    ../app/public/: Queue16.c Queue32.c rt_utils_tlv.c task_timer.c ustrcrc.c ustring.c ustrmath.c
  group app/public/inc
    ../app/public/inc/: Queue.h Queue16.h Queue32.h rt_utils_tlv.h task_timer.h ustring.h
  group app/system
    ../app/system/: ota.c pit.c PPItems.c reg_edit.c uesim.c upgrade.c
  group app/system/inc
    ../app/system/inc/: ota.h PPdef.h PPItems.h reg_edit.h uesim.h upgrade.h
  group bsp/drivers
    ../bsp/drivers/: board.c board.h drv_adc.c drv_common.c drv_common.h drv_gpio.c drv_I2C.c drv_lptim.c drv_lptim.h drv_pm.c drv_pwm.c drv_rng.c drv_rng.h drv_rtc.c drv_soft_i2c.c drv_usart.c LSM6DS3.c LSM6DS3.h mx25uxx.c stm32u5xx_hal_conf.h stm32u5xx_hal_msp.c
    ../bsp/drivers/drv_flash/: drv_flash_u5.c
  group bsp/drivers/include
    ../bsp/drivers/include/: drv_adc.h drv_flash.h drv_flash_if.h drv_gpio.h drv_log.h
    ../bsp/drivers/: drv_config.h
  group bsp/ld
    ../bsp/ld/: stm32u575xx_flash.icf
  group bsp/libraries
    ../bsp/libraries/inc/: flashmap.h
  group bsp/libraries/CMSIS
    ../bsp/libraries/CMSIS/Device/ST/STM32U5xx/Source/Templates/iar/: startup_stm32u575xx.s
    ../bsp/libraries/CMSIS/Core/: system_stm32u5xx.c
  group bsp/libraries/STM32U5xx_HAL_Driver/Inc
    ../bsp/libraries/STM32U5xx_HAL_Driver/Inc/: stm32_assert_template.h stm32u5xx_hal.h stm32u5xx_hal_adc.h stm32u5xx_hal_adc_ex.h stm32u5xx_hal_comp.h stm32u5xx_hal_cordic.h stm32u5xx_hal_cortex.h stm32u5xx_hal_crc.h stm32u5xx_hal_crc_ex.h stm32u5xx_hal_cryp.h stm32u5xx_hal_cryp_ex.h stm32u5xx_hal_dac.h stm32u5xx_hal_dac_ex.h stm32u5xx_hal_dcache.h stm32u5xx_hal_dcmi.h stm32u5xx_hal_def.h stm32u5xx_hal_dma.h stm32u5xx_hal_dma2d.h stm32u5xx_hal_dma_ex.h stm32u5xx_hal_dsi.h stm32u5xx_hal_exti.h stm32u5xx_hal_fdcan.h stm32u5xx_hal_flash.h stm32u5xx_hal_flash_ex.h stm32u5xx_hal_fmac.h stm32u5xx_hal_gfxmmu.h stm32u5xx_hal_gpio.h stm32u5xx_hal_gpio_ex.h stm32u5xx_hal_gpu2d.h stm32u5xx_hal_gtzc.h stm32u5xx_hal_hash.h stm32u5xx_hal_hash_ex.h stm32u5xx_hal_hcd.h stm32u5xx_hal_i2c.h stm32u5xx_hal_i2c_ex.h stm32u5xx_hal_icache.h stm32u5xx_hal_irda.h stm32u5xx_hal_irda_ex.h stm32u5xx_hal_iwdg.h stm32u5xx_hal_lptim.h stm32u5xx_hal_ltdc.h stm32u5xx_hal_ltdc_ex.h stm32u5xx_hal_mdf.h stm32u5xx_hal_mmc.h stm32u5xx_hal_mmc_ex.h stm32u5xx_hal_nand.h stm32u5xx_hal_nor.h stm32u5xx_hal_opamp.h stm32u5xx_hal_opamp_ex.h stm32u5xx_hal_ospi.h stm32u5xx_hal_otfdec.h stm32u5xx_hal_pcd.h stm32u5xx_hal_pcd_ex.h stm32u5xx_hal_pka.h stm32u5xx_hal_pssi.h stm32u5xx_hal_pwr.h stm32u5xx_hal_pwr_ex.h stm32u5xx_hal_ramcfg.h stm32u5xx_hal_rcc.h stm32u5xx_hal_rcc_ex.h stm32u5xx_hal_rng.h stm32u5xx_hal_rng_ex.h stm32u5xx_hal_rtc.h stm32u5xx_hal_rtc_ex.h stm32u5xx_hal_sai.h stm32u5xx_hal_sai_ex.h stm32u5xx_hal_sd.h stm32u5xx_hal_sd_ex.h stm32u5xx_hal_smartcard.h stm32u5xx_hal_smartcard_ex.h stm32u5xx_hal_smbus.h stm32u5xx_hal_smbus_ex.h stm32u5xx_hal_spi.h stm32u5xx_hal_spi_ex.h stm32u5xx_hal_sram.h stm32u5xx_hal_tim.h stm32u5xx_hal_tim_ex.h stm32u5xx_hal_tsc.h stm32u5xx_hal_uart.h stm32u5xx_hal_uart_ex.h stm32u5xx_hal_usart.h stm32u5xx_hal_usart_ex.h stm32u5xx_hal_wwdg.h stm32u5xx_hal_xspi.h stm32u5xx_ll_adc.h stm32u5xx_ll_bus.h stm32u5xx_ll_comp.h stm32u5xx_ll_cordic.h stm32u5xx_ll_cortex.h stm32u5xx_ll_crc.h stm32u5xx_ll_crs.h stm32u5xx_ll_dac.h stm32u5xx_ll_dcache.h stm32u5xx_ll_dlyb.h stm32u5xx_ll_dma.h stm32u5xx_ll_dma2d.h stm32u5xx_ll_exti.h stm32u5xx_ll_fmac.h stm32u5xx_ll_fmc.h stm32u5xx_ll_gpio.h stm32u5xx_ll_i2c.h stm32u5xx_ll_icache.h stm32u5xx_ll_iwdg.h stm32u5xx_ll_lpgpio.h stm32u5xx_ll_lptim.h stm32u5xx_ll_lpuart.h stm32u5xx_ll_opamp.h stm32u5xx_ll_pka.h stm32u5xx_ll_pwr.h stm32u5xx_ll_rcc.h stm32u5xx_ll_rng.h stm32u5xx_ll_rtc.h stm32u5xx_ll_sdmmc.h stm32u5xx_ll_spi.h stm32u5xx_ll_system.h stm32u5xx_ll_tim.h stm32u5xx_ll_ucpd.h stm32u5xx_ll_usart.h stm32u5xx_ll_usb.h stm32u5xx_ll_utils.h stm32u5xx_ll_wwdg.h
  group bsp/libraries/STM32U5xx_HAL_Driver/src
    ../bsp/libraries/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_comp.c stm32u5xx_hal_cordic.c stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_cryp.c stm32u5xx_hal_cryp_ex.c stm32u5xx_hal_dac.c stm32u5xx_hal_dac_ex.c stm32u5xx_hal_dcache.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma2d.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gpu2d.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_hash.c stm32u5xx_hal_hash_ex.c stm32u5xx_hal_hcd.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_iwdg.c stm32u5xx_hal_lptim.c stm32u5xx_hal_mdf.c stm32u5xx_hal_opamp.c stm32u5xx_hal_opamp_ex.c stm32u5xx_hal_ospi.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_rng.c stm32u5xx_hal_rng_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_sram.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_tsc.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_usart.c stm32u5xx_hal_usart_ex.c stm32u5xx_hal_wwdg.c
  group packages/cJSON
    ../packages/packages/cJSON-v1.0.2/: cJSON.c cJSON.h cJSON_port.c cJSON_util.c cJSON_util.h
  group packages/easyblink-v2.0.1
    ../packages/packages/easyblink-v2.0.1/: easyblink.c easyblink.h
  group packages/i2c-tools
    ../packages/packages/i2c-tools-latest/src/: i2c_tools.cpp i2c_utils.cpp i2c_utils.h
  group packages/quick_led-latest
    ../packages/packages/quick_led-latest/src/: qled.c qled_sample.c
    ../packages/packages/quick_led-latest/inc/: qled.h qled_sample.h typedef.h
  group packages/syswatch/inc
    ../packages/packages/syswatch-latest/inc/: syswatch.h syswatch_config.h
  group packages/syswatch/src
    ../packages/packages/syswatch-latest/src/: syswatch.c syswatch_test.c
  group rt-thread[5.0.1]/components/dfs/filesystems/devfs
    ../os/rt-thread5.0.1/components/dfs/dfs_v1/filesystems/devfs/: devfs.c devfs.h
  group rt-thread[5.0.1]/components/dfs/filesystems/uffs/src/inc
    ../os/rt-thread5.0.1/components/dfs/dfs_v1/filesystems/uffs/src/inc/uffs/: uffs.h uffs_badblock.h uffs_blockinfo.h uffs_buf.h uffs_core.h uffs_crc.h uffs_device.h uffs_ecc.h uffs_fd.h uffs_find.h uffs_flash.h uffs_fs.h uffs_mem.h uffs_mtb.h uffs_os.h uffs_pool.h uffs_public.h uffs_tree.h uffs_types.h uffs_utils.h uffs_version.h
  group rt-thread[5.0.1]/components/dfs/filesystems/uffs/src/uffs
    ../os/rt-thread5.0.1/components/dfs/dfs_v1/filesystems/uffs/src/uffs/: uffs_badblock.c uffs_blockinfo.c uffs_buf.c uffs_crc.c uffs_debug.c uffs_device.c uffs_ecc.c uffs_fd.c uffs_find.c uffs_flash.c uffs_fs.c uffs_init.c uffs_mem.c uffs_mtb.c uffs_pool.c uffs_public.c uffs_tree.c uffs_utils.c uffs_version.c
  group rt-thread[5.0.1]/components/dfs/filesystems/uffs/storage
    ../os/rt-thread5.0.1/components/dfs/dfs_v0/filesystems/uffs/storage/: uffs_rtthread.c
  group rt-thread[5.0.1]/components/dfs/filesystems/uffs/storage/nor
    ../os/rt-thread5.0.1/components/dfs/dfs_v0/filesystems/uffs/storage/nor/: dfs_uffs.c dfs_uffs.h uffs_config.h uffs_flashif.c
  group rt-thread[5.0.1]/components/dfs/include
    ../os/rt-thread5.0.1/components/dfs/dfs_v1/include/: dfs.h dfs_file.h dfs_fs.h dfs_private.h
  group rt-thread[5.0.1]/components/dfs/src
    ../os/rt-thread5.0.1/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group rt-thread[5.0.1]/components/drivers/i2c
    ../os/rt-thread5.0.1/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
  group rt-thread[5.0.1]/components/drivers/include/drivers
    ../os/rt-thread5.0.1/components/drivers/include/drivers/: adc.h hwtimer.h i2c-bit-ops.h i2c.h i2c_dev.h lptimer.h pin.h pm.h rtc.h
  group rt-thread[5.0.1]/components/drivers/ipc
    ../os/rt-thread5.0.1/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group rt-thread[5.0.1]/components/drivers/misc
    ../os/rt-thread5.0.1/components/drivers/misc/: adc.c pin.c
  group rt-thread[5.0.1]/components/drivers/pm
    ../os/rt-thread5.0.1/components/drivers/pm/: lptimer.c pm.c
  group rt-thread[5.0.1]/components/drivers/rtc
    ../os/rt-thread5.0.1/components/drivers/rtc/: alarm.c rtc.c
  group rt-thread[5.0.1]/components/drivers/serial
    ../os/rt-thread5.0.1/components/drivers/serial/: serial.c
  group rt-thread[5.0.1]/components/finsh
    ../os/rt-thread5.0.1/components/finsh/: cmd.c finsh.h msh.c msh.h msh_file.c msh_parse.c msh_parse.h shell.c shell.h
  group rt-thread[5.0.1]/components/libc/common
    ../os/rt-thread5.0.1/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group rt-thread[5.0.1]/components/libc/dlib
    ../os/rt-thread5.0.1/components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group rt-thread[5.0.1]/components/utilities/ulog
    ../os/rt-thread5.0.1/components/utilities/ulog/syslog/: syslog.c syslog.h
    ../os/rt-thread5.0.1/components/utilities/ulog/: ulog.c ulog.h ulog_def.h
  group rt-thread[5.0.1]/components/utilities/ulog/backend
    ../os/rt-thread5.0.1/components/utilities/ulog/backend/: console_be.c
  group rt-thread[5.0.1]/components/utilities/utest
    ../os/rt-thread5.0.1/components/utilities/utest/: utest.c utest.h utest_assert.h utest_log.h
  group rt-thread[5.0.1]/components/utilities/ymodem
    ../os/rt-thread5.0.1/components/utilities/ymodem/: ry_sy.c ymodem.c ymodem.h
  group rt-thread[5.0.1]/include
    ../os/rt-thread5.0.1/include/: rtatomic.h rtdbg.h rtdef.h rthw.h rtm.h rtservice.h rtthread.h
  group rt-thread[5.0.1]/libcpu/arm
    ../os/rt-thread5.0.1/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../os/rt-thread5.0.1/libcpu/arm/cortex-m33/: context_iar.S cpuport.c syscall_iar.S trustzone.c
  group rt-thread[5.0.1]/src
    ../os/rt-thread5.0.1/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
